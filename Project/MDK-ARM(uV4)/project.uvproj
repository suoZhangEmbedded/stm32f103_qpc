# Keil uVision project project.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\FreeRTOS\Source\include;..\..\User\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\User\SEGGER_RTT\RTT;..\..\User\MQTTClient-C\MQTTPacket\src;..\..\User\MQTTClient-C\src\FreeRTOS;..\..\User\MQTTClient-C\src;..\..\User\SFUD\inc;..\..\User\littlefs;..\..\User\minmea;..\..\User\uds-c\src;..\..\User\uds-c\deps
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../User/app/src/: main.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_can.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group FreeRTOS
    ../../User/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../User/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../User/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group SEGGER_RTT
    ../../User/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
